KERNEL_URL = "git://github.com/ARIES-Embedded/rz_linux-cip.git"
BRANCH = "msrz-5.10-cip41"
SRCREV = "4c7f347b46b92f47a47629e75fbda9762f2e610d"
