INITRAMFS_SCRIPTS = "initramfs-module-devshell"
BAD_RECOMMENDATIONS += "initramfs-module-rootfs"
