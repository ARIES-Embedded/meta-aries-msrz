FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
SRC_URI += "file://msrz.cfg"
