require u-boot-initial-env.inc
UBOOT_URL = "git://github.com/ARIES-Embedded/renesas-u-boot-cip.git;protocol=https"
BRANCH = "dev/v2021.10/msrz"
SRCREV = "075575540a2347c1d6976b5c11e5e1e74de2801b"
