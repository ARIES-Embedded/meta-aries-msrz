KBUILD_DEFCONFIG = "msrzg2ls_defconfig"
COMPATIBLE_MACHINE_msrzg2ls = "(msrzg2ls)"
