FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

BOARD_msrzg2ls = "RZG2L_SMARC_PMIC"
