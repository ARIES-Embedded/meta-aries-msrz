FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI:append:msrzg3sevk = " \
	file://Flash_Writer_SCIF_MSRZG3EEVK_LPDDR4.mot \
"
