KBUILD_DEFCONFIG = "mrzv2ls_defconfig"
COMPATIBLE_MACHINE_mrzv2ls = "(mrzv2ls)"
BRANCH = "dev/msrz-5.10-cip22"
SRCREV = "${AUTOREV}"
