KBUILD_DEFCONFIG = "msrzfive_defconfig"
COMPATIBLE_MACHINE_msrzfive = "(msrzfive)"
